# Keil uVision project can.uvprojx, settings and files
target can (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user;..\hardware\CAN;..\hardware\KEY;..\hardware\LCD;..\hardware\LED;..\hardware\CAN;..\hardware\TIMER;..\HARDWARE\WDG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_iwdg.c
  group hardware
    ../hardware/CAN/: can.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/LCD/: lcd.c
